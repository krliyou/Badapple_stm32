# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf  --text  -a -c  --output="$L@L.dis"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: __RTTHREAD__, USE_HAL_DRIVER, STM32H750xx, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, RT_USING_LIBC
  c include: applications;..\..\platforms\rt-thread\components\libc\compilers\common\include;..\..\platforms\rt-thread\components\libc\compilers\common\extension;..\..\platforms\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\platforms\rt-thread\libcpu\arm\common;..\..\platforms\rt-thread\libcpu\arm\cortex-m7;..\..\platforms\rt-thread\components\drivers\include;..\..\platforms\rt-thread\components\drivers\include;..\..\platforms\rt-thread\components\drivers\include;..\..\platforms\rt-thread\components\drivers\include;..\..\platforms\rt-thread\components\drivers\spi;..\..\platforms\rt-thread\components\drivers\include;board;board\CubeMX_Config\Core\Inc;board\port;..\..\platforms\rt-thread\bsp\stm32\libraries\HAL_Drivers;..\..\platforms\rt-thread\bsp\stm32\libraries\HAL_Drivers\config;..\..\platforms\rt-thread\bsp\stm32\libraries\HAL_Drivers\CMSIS\Include;..\..\platforms\rt-thread\components\dfs\include;..\..\platforms\rt-thread\components\dfs\filesystems\elmfat;..\..\platforms\rt-thread\components\dfs\filesystems\romfs;..\..\platforms\rt-thread\components\finsh;..\..\src;..\..\src\include;.;..\..\platforms\rt-thread\include;..\..\platforms\rt-thread\bsp\stm32\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\platforms\rt-thread\bsp\stm32\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\platforms\rt-thread\components\libc\posix\io\poll;..\..\platforms\rt-thread\components\libc\posix\io\stdio;..\..\platforms\rt-thread\components\libc\posix\ipc;..\..\src\drivers\gc9a01
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x800000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../platforms/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../platforms/rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../platforms/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../platforms/rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../platforms/rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../platforms/rt-thread/components/drivers/misc/: pin.c
    ../../platforms/rt-thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../platforms/rt-thread/components/drivers/serial/: serial_v2.c
    ../../platforms/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../../platforms/rt-thread/bsp/stm32/libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/: drv_sdio.c filesystem.c
    ../../platforms/rt-thread/bsp/stm32/libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_sdram.c drv_spi.c drv_usart_v2.c
    ../../src/drivers/gc9a01/: drv_gc9a01.c
    ./board/port/: drv_mpu.c
  group Filesystem
    ../../platforms/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../platforms/rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../platforms/rt-thread/components/dfs/src/: dfs_posix.c dfs.c dfs_file.c dfs_fs.c
  group Finsh
    ../../platforms/rt-thread/components/finsh/: msh_parse.c shell.c msh_file.c cmd.c msh.c
  group Kernel
    ../../platforms/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../../platforms/rt-thread/bsp/stm32/libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_uart.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_dma.c stm32h7xx_hal_comp.c stm32h7xx_hal_usart.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sd.c stm32h7xx_hal_cryp_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sram.c
    ../../platforms/rt-thread/bsp/stm32/libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Modules
    ../../src/modules/: badapple.c
